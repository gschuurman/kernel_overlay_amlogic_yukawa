## Kconfig.ext
```kconfig
# SPDX-License-Identifier: GPL-2.0

source "$(srctree)/../yukawa-device/drivers/gpu/arm/Kconfig"
```
